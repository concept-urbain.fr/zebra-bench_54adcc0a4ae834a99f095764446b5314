Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: Zebra banc.IFC
Time: 2020-07-01T10:14:10
Written by: SwIFC
Made in: SolidWorks 2019

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0

# IfcBuildingElementProxy: Zebra banc
In: Default Storey
Material: S 235
PSet_Mass_Property - Mass Measure: 53.601; Area Measure: 3.11128; Volume Measure: 0.00696117
